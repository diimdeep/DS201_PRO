# IAR project DS201V4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\USB_lib\Inc; ..\STD_lib\Inc; ..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DS201V4.hex
  ILINK.IlinkOutputFile: DS201V4.out
  ILINK.IlinkIcfFile: stm32f10x_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCIncludePath2: ..\library\Inc; ..\include; 
  group ASM
    ../Src/: Cm3_macro.s DFU_Func.s Display.o
  group Program
    ../Src/: Bios.c Calculate.c Draw.c Ext_Flash.c FAT12.c Files.c Func.c HDW_Config.c Interrupt.c Main.c Memory.c Menu.c Process.c scsi_data.c USB_bot.c USB_desc.c USB_endp.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c Vector.c
  group STD_Lib
    ../STD_lib/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group USB_Lib
    ../USB_Lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
