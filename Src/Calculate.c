/******************** (C) COPYRIGHT 2009 e-Design Co.,Ltd. *********************
 Project Name: DS0201_LIB         Author: kewei & bure            Version: 2.21
*******************************************************************************/

#include "Calculate.h"

/*******************************************************************************
 Char_to_Str: Change Byte to 3 decimal number string   
*******************************************************************************/
void Char_to_Str(unsigned char *p, unsigned char n)
{
    *p++ = '0'+n/100;
    n %= 100;
    *p++ = '0'+n/10;
    n %= 10;
    *p++ = '0'+n;
    *p = 0;
}
/*******************************************************************************
 Char_to_Hex: Change Byte to 2 hex number string  
*******************************************************************************/
void Char_to_Hex(unsigned char *p, unsigned char n)
{
    if(n/16>9)
      *p++ = 'A'+(n/16-10);
    else
      *p++ = '0'+n/16;
    n %= 16;
    if(n>9)
      *p++ = 'A'+(n-10);
    else
      *p++ = '0'+n;
    *p++ = ' ';
    *p = 0;
}
/*******************************************************************************
 Int_sqrt: unsigned int square root
*******************************************************************************/
int Int_sqrt(unsigned int n)
{ int k;
  if ( n == 0 ) return 0;
  k = 2*Int_sqrt(n/4)+1;
  if ( k*k > n ) return k-1;
  else return k;
}

/********************************* END OF FILE ********************************/
